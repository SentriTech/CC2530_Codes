# IAR project project2.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: source/Components/utils; source/Components/hal; source/Components/basicrf
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2530b.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  group apps
    source/apps/: main.c
  group basic rf
    source/components/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group hal
    source/components/hal/: clock.c clock.h hal_assert.c hal_assert.h hal_board.c hal_board.h hal_cc8051.h hal_defs.h hal_int.c hal_int.h hal_led.c hal_led.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_rf_security.c hal_rf_security.h hal_rf_util.c hal_rf_util.h hal_timer_32k.c hal_timer_32k.h hal_types.h hal_uart.c hal_uart.h
  group utilities
    source/components/utils/: util.c util.h
